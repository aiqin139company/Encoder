# Keil uVision project EncoderTest.uvprojx, settings and files
target EncoderTest (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EncoderTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4,STM32F40XX,USE_STDPERIPH_DRIVER
  c include: ..\DeviceSupport\CMSIS;..\DeviceSupport\CMSIS\Include;..\DeviceSupport\SYS_NVIC;..\DeviceSupport\STM32F4xx_StdPeriph_Driver\inc;..\UnityTest\Src;..\UnityTest\Test;..\CodeSources\Control\Headers;..\CodeSources\Driver\Headers;..\CodeSources\Hardware\Headers;..\CodeSources\Tester\Headers;..\CodeSources\UIInterface\Headers;..\CodeSources\Communication\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../DeviceSupport/SYS_NVIC/: cm4_system_nvic.c
    ../DeviceSupport/CMSIS/: system_stm32f4xx.c startup_stm32f40xx.s
    ../DeviceSupport/CMSIS/Library/: arm_cortexM4lf_math.lib
  group DeviceSupport
    ../DeviceSupport/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP
    ../CodeSources/Hardware/Souce/: Uart.c LCD12864.c Key.c
  group Control
    ../CodeSources/Control/Souce/: main.cpp ControlManager.cpp CommManager.cpp DriverManager.cpp EncoderManager.cpp UIManager.cpp BSPManager.cpp
  group Driver
    ../CodeSources/Driver/Source/: BaseDriver.cpp ACBrushless.cpp DCBrushed.cpp StepDirSignal.cpp Stepper.cpp Switch.cpp
  group Encoder
    ../CodeSources/Tester/Source/: BaseTester.cpp CaptureTest.cpp CountPulse.cpp PhaseShift.cpp
  group Communication
    ../CodeSources/Communication/Source/: BaseComm.cpp SciComm.cpp
  group UIInterface
    ../CodeSources/UIInterface/Source/: UIInterface.cpp CommUI.cpp DriverUI.cpp HomeUI.cpp MenuUI.cpp EncoderUI.cpp SettingsUI.cpp TestUI.cpp
